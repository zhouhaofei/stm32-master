# Keil uVision project STM32F407-FreeRTOS TCPIP.uvprojx, settings and files
target Target (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F407-FreeRTOS TCPIP +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: .\CMSIS;.\Library\inc;.\FreeRTOS;.\FreeRTOS\include;.\FreeRTOS\portable;.\FreeRTOS-Plus-TCP;.\FreeRTOS-Plus-TCP\Compiler;.\FreeRTOS-Plus-TCP\include;.\STM32F4x7_ETH_Driver;.\LAN8720;.\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ./CMSIS/: system_stm32f4xx.c
  group Startup
    ./Startup/: startup_stm32f40_41xxx.s 注意事项.txt
  group Library
    ./Library/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ./Library/: 注意事项.txt
  group FreeRTOS-Source
    ./FreeRTOS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c readme.txt
  group FreeRTOS-MemMang
    ./FreeRTOS/MemMang/: heap_5.c 五种内存分配说明.txt
  group FreeRTOS-Portable
    ./FreeRTOS/portable/: port.c portmacro.h
  group FreeRTOS-Config
    ./FreeRTOS/: FreeRTOSConfig.h FreeRTOSHook.c
  group FreeRTOS-TCPIP-Source
    ./FreeRTOS-Plus-TCP/source/: FreeRTOS_ARP.c FreeRTOS_DHCP.c FreeRTOS_DNS.c FreeRTOS_IP.c FreeRTOS_Sockets.c FreeRTOS_Stream_Buffer.c FreeRTOS_TCP_IP.c FreeRTOS_TCP_WIN.c FreeRTOS_UDP_IP.c History.txt
  group FreeRTOS-TCPIP-BufferManage
    ./FreeRTOS-Plus-TCP/BufferManagement/: BufferAllocation_2.c 两种网络缓冲区分配方案.txt
  group FreeRTOS-TCPIP-Config
    ./FreeRTOS-Plus-TCP/: FreeRTOSIPConfig.h FreeRTOSIPHook.c
  group ETH_Driver
    ./STM32F4x7_ETH_Driver/: stm32f4x7_eth.c stm32f4x7_eth.h stm32f4x7_eth_conf.h
  group LAN8720
    ./LAN8720/: LAN8720.c LAN8720.h
  group User
    ./User/: main.c stm32f4xx_it.c public.c mQueue.c
